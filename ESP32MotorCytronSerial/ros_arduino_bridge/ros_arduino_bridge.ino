/*
 * ROS Arduino / ESP32 Bridge for VierBot
 * Communicates with diffdrive_arduino ROS 2 control hardware interface over USB Serial
 */

#include "commands.h"
#include "motor_driver.h"
#include "encoder_driver.h"

#define BAUDRATE 115200
#define AUTO_STOP_INTERVAL 1000 // Stop motors if no command received in 1 sec

long lastMotorCommand = 0;

// Serial Parsing Variables
char chr;
char val[16];
int arg = 0;
int index_val = 0;
char cmd;
long arg1 = 0;
long arg2 = 0;

void resetCommand() {
    cmd = 0;
    memset(val, 0, sizeof(val));
    index_val = 0;
    arg = 0;
    arg1 = 0;
    arg2 = 0;
}

int runCommand() {
    int i = 0;
    char *p = val;
    char *str;
    int pid_args[4];

    switch(cmd) {
        case READ_ENCODERS:
            Serial.print(readEncoder(LEFT));
            Serial.print(" ");
            Serial.println(readEncoder(RIGHT));
            break;

        case RESET_ENCODERS:
            resetEncoders();
            Serial.println("OK");
            break;

        case MOTOR_SPEEDS:
            lastMotorCommand = millis();
            // arg1 = left speed, arg2 = right speed
            setMotorSpeeds((int)arg1, (int)arg2);
            Serial.println("OK");
            break;

        case UPDATE_PID:
            while ((str = strtok_r(p, ":", &p)) != NULL) {
                pid_args[i] = atoi(str);
                i++;
            }
            Serial.println("OK");
            break;

        case PING:
            Serial.println("OK");
            break;

        default:
            Serial.println("Invalid Command");
            break;
    }
    return 0;
}

void setup() {
    Serial.begin(BAUDRATE);
    initEncoders();
    initMotorController();
    resetCommand();
    lastMotorCommand = millis();
}

void loop() {
    while (Serial.available() > 0) {
        chr = Serial.read();

        // End of line command execution
        if (chr == 13 || chr == 10) {
            if (arg == 1) arg1 = atol(val);
            else if (arg == 2) arg2 = atol(val);
            runCommand();
            resetCommand();
        }
        // Delimiter
        else if (chr == ' ') {
            if (arg == 0) arg = 1;
            else if (arg == 1) {
                arg1 = atol(val);
                arg = 2;
                memset(val, 0, sizeof(val));
                index_val = 0;
            }
        }
        else {
            if (arg == 0) {
                cmd = chr;
            } else {
                if (index_val < 15) {
                    val[index_val] = chr;
                    index_val++;
                    val[index_val] = '';
                }
            }
        }
    }

    // Safety watchdog: stop motors on timeout
    if ((millis() - lastMotorCommand) > AUTO_STOP_INTERVAL) {
        setMotorSpeeds(0, 0);
    }
}
